v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {inverter.sym} 200 90 0 0 {name=x1}
